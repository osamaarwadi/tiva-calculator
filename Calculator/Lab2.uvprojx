# Keil uVision project Lab2.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c TExaS.h clockInit.c clockinit.h portInit.h portInit.c lcd.h lcd.c keypad.c keypad.h calculator.h calculator.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
